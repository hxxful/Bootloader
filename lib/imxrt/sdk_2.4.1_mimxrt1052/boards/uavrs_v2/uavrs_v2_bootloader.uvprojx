# Keil uVision project uavrs_v2_bootloader.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: uavrs_v2_bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG=0,NDEBUG=1,RTE_USART0,RTE_USART0_DMA_EN,CPU_MIMXRT1052DVL6B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,CPU_IS_ARM_CORTEX_M7=1,USE_RAM_VECTOR_TABLE
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\CMSIS\Include;..\..\devices\MIMXRT1052;..\..\devices\MIMXRT1052\drivers;..\..\devices\MIMXRT1052\utilities;..\..\devices\MIMXRT1052\utilities\io;..\..\devices\MIMXRT1052\utilities\log;..\..\devices\MIMXRT1052\utilities\str;.\demo_apps\test;.\demo_apps\test\xip;.\demo_apps\test\bsp
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_itcm_txt_ram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
  group Source Group 1
    ../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
    ../../devices/MIMXRT1052/: system_MIMXRT1052.c
    ../../devices/MIMXRT1052/drivers/: fsl_clock.c fsl_common.c fsl_flexspi.c fsl_gpio.c fsl_lpuart.c
    ../../devices/MIMXRT1052/utilities/: fsl_assert.c fsl_debug_console.c fsl_notifier.c fsl_sbrk.c fsl_shell.c
    ../../devices/MIMXRT1052/utilities/str/: fsl_str.c
    ../../devices/MIMXRT1052/utilities/log/: fsl_log.c
    ../../devices/MIMXRT1052/utilities/io/: fsl_io.c
    ./demo_apps/test/: board.c clock_config.c pin_mux.c
    ./demo_apps/test/xip/: fsl_flexspi_nor_boot.c uavrs_v2_flexspi_nor_flash.c uavrs_v2_sdram_ini_dcd.c
    ./demo_apps/test/bsp/led/: bsp_led.c
    ../../../../../: main_imxrt1052.c
