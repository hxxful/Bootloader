# IAR project lwip_httpsrv_freertos.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SKIP_SYSCLK_INIT; DEBUG; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1052DVL6B; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ..; ../../../../../../../middleware/lwip/src/apps/httpsrv; ../../../../..; ../../../../../../../rtos/amazon-freertos/lib/include; ../../../../../../../rtos/amazon-freertos/lib/include/private; ../../../../../../../devices/MIMXRT1052/drivers; ../../../../../../../devices/MIMXRT1052; ../../../../../../../devices/MIMXRT1052/utilities/io; ../../../../../../../devices/MIMXRT1052/utilities/str; ../../../../../../../devices/MIMXRT1052/utilities/log; ../../../../../../../devices/MIMXRT1052/utilities; ../../../../../../../devices/MIMXRT1052/xip; ../../../../../../../middleware/lwip/port; ../../../../../../../middleware/lwip/src; ../../../../../../../middleware/lwip/src/include; ../../../../../../../middleware/lwip/contrib/apps
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../../../..
  ILINK.IlinkOutputFile: lwip_httpsrv_freertos.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1052DVL6B; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=1; FSL_RTOS_FREE_RTOS
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1052DVL6B; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=1; FSL_RTOS_FREE_RTOS
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; NDEBUG; SKIP_SYSCLK_INIT; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1052DVL6B; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=1; FSL_RTOS_FREE_RTOS
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1052DVL6B; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=1; FSL_RTOS_FREE_RTOS
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FSL_FEATURE_PHYKSZ8081_USE_RMII50M_MODE; CPU_MIMXRT1052DVL6B; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; HTTPSRV_CFG_WEBSOCKET_ENABLED=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
  group source
    ../: lwip_httpsrv_freertos.c lwipopts.h FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h fsl_phy.h fsl_phy.c
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MIMXRT1052/drivers/: fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_lpuart.h fsl_lpuart.c fsl_iomuxc.h fsl_gpio.h fsl_gpio.c fsl_enet.h fsl_enet.c
  group startup
    ../../../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
    ../../../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group utilities
    ../../../../../../../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MIMXRT1052/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group xip
    ../../../../../../../devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c evkbimxrt1050_hyper_config.c evkbimxrt1050_hyper_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
  group lwip/src/apps/httpsrv
    ../../../../../../../middleware/lwip/src/apps/httpsrv/: httpsrv.c httpsrv.h httpsrv_base64.c httpsrv_base64.h httpsrv_config.h httpsrv_fs.c httpsrv_fs.h httpsrv_fs_data.c httpsrv_port.h httpsrv_prv.h httpsrv_script.c httpsrv_script.h httpsrv_sha1.c httpsrv_sha1.h httpsrv_supp.c httpsrv_supp.h httpsrv_task.c httpsrv_tls.c httpsrv_tls.h httpsrv_utf8.c httpsrv_utf8.h httpsrv_ws.c httpsrv_ws.h httpsrv_ws_api.c httpsrv_ws_prv.h
  group lwip/src/api
    ../../../../../../../middleware/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/core
    ../../../../../../../middleware/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    ../../../../../../../middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    ../../../../../../../middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/lwip
    ../../../../../../../middleware/lwip/src/include/lwip/: api.h arch.h debug.h dhcp.h dns.h errno.h ethip6.h icmp6.h inet.h init.h ip_addr.h ip4_addr.h ip6.h ip6_frag.h memp.h nd6.h netdb.h netifapi.h pbuf.h sio.h sockets.h sys.h tcpip.h udp.h autoip.h def.h dhcp6.h err.h etharp.h icmp.h igmp.h inet_chksum.h ip.h ip4.h ip4_frag.h ip6_addr.h mem.h mld6.h netbuf.h netif.h opt.h raw.h snmp.h stats.h tcp.h timeouts.h
  group lwip/src/include/lwip/priv
    ../../../../../../../middleware/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    ../../../../../../../middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    ../../../../../../../middleware/lwip/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group lwip/src/include/netif/ppp
    ../../../../../../../middleware/lwip/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    ../../../../../../../middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/include/posix
    ../../../../../../../middleware/lwip/src/include/posix/: errno.h netdb.h
  group lwip/src/include/posix/sys
    ../../../../../../../middleware/lwip/src/include/posix/sys/: socket.h
  group lwip/src/netif
    ../../../../../../../middleware/lwip/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip/src/netif/ppp
    ../../../../../../../middleware/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/port
    ../../../../../../../middleware/lwip/port/: ethernetif.c ethernetif.h sys_arch.c
  group lwip/port/arch
    ../../../../../../../middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group amazon-freertos/FreeRTOS
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/FreeRTOS/portable
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_3.c
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group amazon-freertos/license
    ../../../../../../../rtos/amazon-freertos/: LICENSE
  group amazon-freertos/include
    ../../../../../../../rtos/amazon-freertos/lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group amazon-freertos/portable
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h
